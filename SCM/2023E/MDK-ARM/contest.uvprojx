# Keil uVision project contest.uvprojx, settings and files
target contest (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: contest +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./contest/FreeRTOS/include;./contest/FreeRTOS/port/RVDS/ARM_CM3;../Algorithm;../Hardware;../Configuration
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Inc/: global.h
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group FreeRTOS
    ./contest/FreeRTOS/src/: list.c croutine.c event_groups.c queue.c stream_buffer.c tasks.c timers.c
    ./contest/FreeRTOS/port/RVDS/ARM_CM3/: port.c
    ./contest/FreeRTOS/port/MemMang/: heap_4.c
  group Algorithm
    ../Algorithm/: pid.c pid.h filter.h filter.c myMath.c myMath.h mutex_lock_and_message_queue.c mutex_lock_and_message_queue.h data_protocol.c data_protocol.h
  group Hardware
    ../Hardware/: servo.c servo.h oled.c oled.h codetap.h mpu6050.c mpu6050.h imu.c imu.h motor.c motor.h eletube.c eletube.h keys.c keys.h
  group Configuration
    ../Configuration/: timer.c timer.h
software components: CMSIS:CORE 4.3.0
